# IAR project STM32L-Discovery.ewp, settings and files
configuration STM32L-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152x8 ST STM32L152x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L15XXB_128K; USE_FULL_ASSERT; USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\libraries\STM32_TouchSensing_Driver\inc; ..\..\..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\..\Utilities\STM32L-DISCOVERY
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L-Discovery.hex
  ILINK.IlinkOutputFile: STM32L-Discovery.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Doc
    ../: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group User
    ../src/: discover_functions.c icc_measure.c icc_measure_Ram.c main.c stm32l1xx_it.c system_stm32l1xx.c
